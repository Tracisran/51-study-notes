# Keil uVision project 测距.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 测距 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./超声波测距51C程序/: 51.C
